# Keil uVision project Music Box.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Music Box
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: MusicBox.c tm4c123gh6pm.h ST7735.h PLL.h ADC.h DAC.h LCD.h Sound.h ADC.c DAC.c PLL.c Sound.c ST7735.c Timer0.c Timer1.c Timer0.h Timer1.h Timer2.c Timer2.h startup.s LCD.s
